# Keil uVision project F4_Template.uvprojx, settings and files
target uC-OS3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\App;..\Drivers\BSP;..\Drivers\CMSIS;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\SYSTEM;..\Middlewares;..\Middlewares\uC-OS3\uC-CPU\Cfg\Template;..\Middlewares\uC-OS3\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\Middlewares\uC-OS3\uC-CPU;..\Middlewares\uC-OS3\uC-LIB\Cfg\Template;..\Middlewares\uC-OS3\uC-LIB;..\Middlewares\uC-OS3\uC-OS3\Cfg\Template;..\Middlewares\uC-OS3\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\Middlewares\uC-OS3\uC-OS3\Source;..\Drivers\BSP\usart;..\Drivers\BSP\key;..\Drivers\BSP\exti;..\Drivers\BSP\lcd;..\Drivers\SYSTEM\delay;..\Drivers\BSP\iic;..\Drivers\BSP\mpu6050;..\App;..\Drivers\BSP\encoder;..\Drivers\BSP\tim;..\Drivers\BSP\pid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/: startup_stm32f40_41xxx.s
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group App
    ../App/: task.c sys_monitor.c
  group Drivers/BSP
    ../Drivers/BSP/: bsp.c
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/usart/: usart.c task_usart.c
    ../Drivers/BSP/key/: key.c
    ../Drivers/BSP/exti/: exti.c exti.h
    ../Drivers/BSP/lcd/: lcd.c lcd_init.c task_lcd.c
    ../Drivers/BSP/iic/: iic.c
    ../Drivers/BSP/mpu6050/: mpu6050.c task_mpu.c
    ../Drivers/BSP/motor/: motor.c
    ../Drivers/BSP/encoder/: encoder.c task_encoder.c
    ../Drivers/BSP/tim/: tim.c
    ../Drivers/BSP/pid/: pid.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middlewares/uC-OS3/BSP
    ../Middlewares/uC-OS3/uC-CPU/BSP/Template/: bsp_cpu.c
    ../Middlewares/uC-OS3/uC-OS3/Template/: bsp_os_dt.c
  group Middlewares/uC-OS3/CPU
    ../Middlewares/uC-OS3/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../Middlewares/uC-OS3/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../Middlewares/uC-OS3/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS3/LIB
    ../Middlewares/uC-OS3/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS3/OS3
    ../Middlewares/uC-OS3/uC-OS3/Cfg/Template/: os_app_hooks.c
    ../Middlewares/uC-OS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ../Middlewares/uC-OS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../Middlewares/uC-OS3/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
